# Keil uVision project S3C2416.uvproj, settings and files
target S3C2416 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: S3C2416 Samsung
  cpu: IRAM(0x40000000-0x4000FFFF) IROM(0x00000000-0x00007FFF) CPUTYPE(ARM926EJ-S)
  output: S3C2416 +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\@L.bin"
  AfterMake: fromelf -c ".\Objects\@L.axf" -o  ".\@L.asm"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\System;..\eurocode;..\Apps;..\Fatfs;..\Driver;..\Lwip\include;..\Lwip\include\ipv4;..\Lwip\include\netif;..\Lwip\include\posix;..\Lwip\port\include;..\Lwip\port\include\arch;..\Common;..\uCOS-II\Cfg;..\uCOS-II\Ports;..\uCOS-II\Source
  memory RVCT1: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x40000000 size 0x10000
  scatter file: ..\System\s3c2416.sct
  group Apps
    ../Apps/: main.c Driver.c RTC.c httpd.c tftputils.c tftpserver.c
  group Driver
    ../Driver/: DM9000.c
  group System
    ../System/: Exception.c MMU.c NAND.c LowLevelInit.s s3c2416.s UART2416.C Timer_IRQ.c WDC.c adc.c Hsmmc.c Retarget.c
  group user
    ../eurocode/: yqadc.c yqcoin.c yqfile.c yqscreen.c yqsqlite3.c yqdrive.c AD_filter.c log.c my_cmd.c
  group Abstract
    ./: README.TXT
  group FatFs
    ../Fatfs/: diskio.c ff.c
    ../Fatfs/option/: ccsbcs.c
  group uCOS-II/Cfg
    ../uCOS-II/Cfg/: os_cfg.h
  group uCOS-II/Ports
    ../uCOS-II/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uCOS-II/Source
    ../uCOS-II/Source/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group Lwip/api
    ../Lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip/core
    ../Lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group Lwip/core/ipv4
    ../Lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Lwip/core/snmp
    ../Lwip/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
  group Lwip/netif
    ../Lwip/netif/: etharp.c slipif.c
  group Lwip/netif/ppp
    ../Lwip/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group Lwip/port
    ../Lwip/port/: ethernetif.c sys_arch.c
  group Lwip/port/include
    ../Lwip/port/include/: lwipopts.h
    ../Lwip/port/include/arch/: cc.h perf.h sys_arch.h
